# Keil uVision project wang_luo_1.uvproj, settings and files
target 目标 1 (MCS-51)
  device: SST89C58 SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(33000000)
  output: wang_luo_1
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: STARTUP.A51 wang_luo_1.c
